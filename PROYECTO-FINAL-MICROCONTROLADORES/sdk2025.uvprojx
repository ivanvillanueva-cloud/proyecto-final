# Keil uVision project sdk2025.uvprojx, settings and files
target sdk (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdk2025 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c usart.c i2c.c BME280.c Satelite.c lcd.c gpio.c
  group User library
    ./: interrupts.h usart.h i2c.h BME280.h lcd.h gpio.h
  group system library
    ./: systickdelay.c systickdelay.h delay.c delay.h Satelite.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
